# Keil uVision project TEXT_USART.uvprojx, settings and files
target TEXT_USART (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: TEXT_USART +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,ARM_MATH_CM7,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__TARGET_FPU_VFP,STB_DS_IMPLEMENTATION,STM32H750xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../CubotMiddleware/dr16;../User;../CubotMiddleware/drivers;../CubotMiddleware/cubotdevice/motor;../CubotMiddleware/Algorithms;../CubotMiddleware/Support;../CubotMiddleware/cubotdevice/check;../CubotMiddleware/cubotdevice;../CubotMiddleware/cubotmodules;../CubotMiddleware/interaction;../CubotMiddleware/referee;../CubotMiddleware/et08
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group CUBOT/device
    ../CubotMiddleware/dr16/: dr16.c
    ../CubotMiddleware/cubotdevice/motor/: motor.c
    ../CubotMiddleware/cubotdevice/check/: check.c
    ../CubotMiddleware/cubotdevice/: servo.c
    ../CubotMiddleware/interaction/: interaction.c interaction_image.c interaction_image.h
    ../CubotMiddleware/referee/: referee.c
    ../CubotMiddleware/et08/: et08.c
    ../User/: state_machines.c referee_control.c motion_control.c display_comm.c
  group Cubot/driver
    ../CubotMiddleware/drivers/: driver_usart.c driver_can.c driver_timer.c driver_iic.c
  group User/Config
    ../User/: control_logic.c hardware_config.c
  group Application/User/Core
    ../CubotMiddleware/Algorithms/: pid.c
    ../Core/Src/: main.c gpio.c dma.c fdcan.c i2c.c memorymap.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Cubot/Algorithm
    ../CubotMiddleware/Algorithms/: kalman.c
    ../CubotMiddleware/cubotdevice/: filter.c
software components: CMSIS:CORE 5.6.0
